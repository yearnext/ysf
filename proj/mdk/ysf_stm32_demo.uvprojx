# Keil uVision project ysf_stm32_demo.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ysf_stm32_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: ..\..\core;..\..\demo;..\..\framework;..\..\common;..\..\hal;..\..\bsp\stm32f1xx\map;..\..\bsp\stm32f1xx\startup;..\..\bsp\stm32f1xx\CMSIS;..\..\bsp\stm32f1xx\msp;..\..\bsp\stm32f1xx\msp\ll_lib;..\..\bsp\stm32f1xx\msp\hal_lib;..\..\bsp\stm32f1xx\msp\hal_lib\Legacy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../../demo/: demo.c app_conf.h
  group ysf/framework
    ../../framework/: fw_task.c fw_tick.c fw_timer.c fw_buffer.c fw_memory.c fw_signal.c fw_debug.c fw_linklist.c fw_core.c fw_pt.c fw_stream.c fw_comm.c fw_pipe.c
  group ysf/hal
    ../../hal/: hal_gpio.c hal_spi.c hal_timer.c hal_device.c hal_uart.c
  group bsp/startup
    ../../bsp/stm32f1xx/startup/: system_stm32f1xx.c
    ../../bsp/stm32f1xx/startup/arm/: startup_stm32f103xe.s
  group bsp/map
    ../../bsp/stm32f1xx/map/: map_uart.c map_gpio.c map_timer.c
  group bsp/msp
    ../../bsp/stm32f1xx/msp/: stm32f1xx.h
    ../../bsp/stm32f1xx/msp/hal_lib/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
software components: CMSIS:CORE 5.0.1
