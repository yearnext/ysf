# IAR project ysf_stm8_alpha.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C8 STM8L152C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\demo; ..\..\framework
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: ysf_stm8_alpha.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group demo
    ../../demo/: demo.c
  group framework
    ../../framework/: fw_conf.h fw_core.c fw_core.h fw_debug.c fw_debug.h fw_event.c fw_event.h fw_queue.c fw_queue.h fw_signal.c fw_signal.h fw_stream.c fw_stream.h fw_tick.c fw_tick.h fw_timer.c fw_timer.h
