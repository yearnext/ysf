# IAR project ysf_stm32_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\common; ..\..\demo; ..\..\framework; ..\..\hal; ..\..\stack; ..\..\bsp\stm32f1xx\startup; ..\..\bsp\stm32f1xx\CMSIS; ..\..\bsp\stm32f1xx\map; ..\..\bsp\stm32f1xx\msp; ..\..\bsp\stm32f1xx\msp\ll_lib; ..\..\bsp\stm32f1xx\msp\hal_lib; ..\..\bsp\stm32f1xx\msp\hal_lib\Legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ysf_stm32_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../demo/: app_conf.h demo.c
  group framework/buffer
    ../../framework/: fw_buffer.c fw_buffer.h
  group framework/core
    ../../framework/: fw_conf.h fw_core.c fw_core.h fw_path.h fw_type.h
  group framework/debug
    ../../framework/: fw_debug.c fw_debug.h
  group framework/linklist
    ../../framework/: fw_linklist.c fw_linklist.h
  group framework/memory
    ../../framework/: fw_memory.c fw_memory.h
  group framework/protothread
    ../../framework/: fw_pt.c fw_pt.h
  group framework/signal
    ../../framework/: fw_signal.c fw_signal.h
  group framework/stream
    ../../framework/: fw_stream.c fw_stream.h
  group framework/stream/uartstream
    ../../framework/: fw_uartstream.c fw_uartstream.h
  group framework/task
    ../../framework/: fw_task.c fw_task.h
  group framework/tick
    ../../framework/: fw_tick.c fw_tick.h
  group framework/timer
    ../../framework/: fw_timer.c fw_timer.h
  group hal/core
    ../../hal/: hal_conf.h hal_core.h hal_type.h
  group hal/gpio
    ../../hal/: hal_gpio.c hal_gpio.h
  group hal/spi
    ../../hal/: hal_spi.c hal_spi.h
  group hal/timer
    ../../hal/: hal_timer.c hal_timer.h
  group hal/uart
    ../../hal/: hal_uart.c hal_uart.h
  group hardware/map/gpio
    ../../bsp/stm32f1xx/map/: map_gpio.c map_gpio.h
  group hardware/map/spi
    ../../bsp/stm32f1xx/map/: map_spi.c map_spi.h
  group hardware/map/timer
    ../../bsp/stm32f1xx/map/: map_timer.c map_timer.h
  group hardware/map/uart
    ../../bsp/stm32f1xx/map/: map_uart.c map_uart.h
  group hardware/msp/lib
    ../../bsp/stm32f1xx/msp/: stm32f1xx.h
    ../../bsp/stm32f1xx/msp/ll_lib/: stm32f1xx_ll_adc.c stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.c stm32f1xx_ll_crc.h stm32f1xx_ll_dac.c stm32f1xx_ll_dac.h stm32f1xx_ll_dma.c stm32f1xx_ll_dma.h stm32f1xx_ll_exti.c stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.c stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.c stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.c stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.c stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.c stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.c stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.c stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.c stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.c stm32f1xx_ll_tim.h stm32f1xx_ll_usart.c stm32f1xx_ll_usart.h stm32f1xx_ll_usb.c stm32f1xx_ll_usb.h stm32f1xx_ll_utils.c stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
  group hardware/msp/startup
    ../../bsp/stm32f1xx/startup/iar/: startup_stm32f103xe.s
    ../../bsp/stm32f1xx/startup/: system_stm32f1xx.c system_stm32f1xx.h
